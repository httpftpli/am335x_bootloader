# IAR project mmc_inand_fat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x
  ICCARM.CCDiagSuppress: Pa050,Pe1750
  ICCARM.CCIncludePath2: ..\..\..\lib\peri_drivers\include\; ..\..\..\lib\peri_drivers\include\hw\; ..\..\..\lib\mmcsdlib\include\; ..\..\..\lib\platform\include\; ..\..\..\lib\cpu\include\; ..\..\..\lib\fatfs\src\; ..\..\..\lib\fatfs\port\; ..\..\..\lib\usblib\include\; ..\..\..\lib\cpu\include\armv7a\; ..\..\..\lib\utils\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\lib\peri_drivers\include\hw\
  OBJCOPY.OOCOutputFile: mmc_inand_fat.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\tool\ewarm\am335x.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../../lib/tool/ewarm/: am335x.icf
    ../../../src/mmc_inand_fat/: mmc_inand_fat.c
  group lib/cpu
    ../../../lib/cpu/armv7a/: cache.c mmu.c
    ../../../lib/cpu/: clock.c interrupt.c startup.c
    ../../../lib/cpu/armv7a/ewarm/: cp15.S cpu.S init.S
    ../../../lib/cpu/ewarm/: exceptionhandler.S
  group lib/fatfs/port
    ../../../lib/fatfs/port/: diskio.c diskio.h
  group lib/fatfs/src
    ../../../lib/fatfs/src/option/: cc936.c
    ../../../lib/fatfs/src/: ff.c ff.h ff_ext.c ff_ext.h ffconf.h integer.h
  group lib/mmcsdlib
    ../../../lib/mmcsdlib/: mmcsd_proto.c mmcsdhost.c
  group lib/per_drivers
    ../../../lib/peri_drivers/: cpsw.c dcan.c dmtimer.c ecap.c edma.c ehrpwm.c elm.c gpio_v2.c gpmc.c hs_mmcsd.c hsi2c.c mailbox.c mcasp.c mcspi.c mdio.c phy.c raster.c rtc.c tsc_adc.c uart_irda_cir.c usb.c usbphyGS70.c watchdog.c
  group lib/platform
    ../../../lib/platform/: pf_cpsw.c pf_dcan.c pf_dmtimer.c pf_edma.c pf_gpio.c pf_hs_mmcsd.c pf_hsi2c.c pf_int.c pf_mux.h pf_platform.c pf_rtc.c pf_sysdelay.c pf_sysperf.c pf_timertick.c pf_uart.c pf_uartConsole.c pf_usb.c pf_watchdog.c
  group lib/utils
    ../../../lib/utils/: cmdline.c delay.c misc.c perf.c systick.c uartStdio.c
