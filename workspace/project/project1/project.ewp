# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; beaglebone; INNERBOOT; DEBUG_DEBUG_NOTOUTPUT; DEBUG_ERROR_NOTOUTPUT; WAJI
  ICCARM.CCDiagSuppress: Pa050,Pe1750
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\lib\peri_drivers\include\; ..\..\..\lib\peri_drivers\include\hw\; ..\..\..\lib\mmcsdlib\include\; ..\..\..\lib\platform\include\; ..\..\..\lib\cpu\include\; ..\..\..\lib\fatfs\src\; ..\..\..\lib\fatfs\port\; ..\..\..\lib\usblib\include\; ..\..\..\lib\cpu\include\armv7a\; ..\..\..\lib\utils\include\; ..\..\..\lib\font\; ..\..\..\lib\gui\; ..\..\..\src\include\; ..\..\..\src\config\; ..\..\..\src\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\lib\peri_drivers\include\hw\
  OBJCOPY.OOCOutputFile: boot_w.mbt
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\tool\ewarm\boot.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone
  ICCARM.CCIncludePath2: ..\..\..\lib\peri_drivers\include\; ..\..\..\lib\peri_drivers\include\hw\; ..\..\..\lib\mmcsdlib\include\; ..\..\..\lib\platform\include\; ..\..\..\lib\cpu\include\; ..\..\..\lib\fatfs\src\; ..\..\..\lib\fatfs\port\; ..\..\..\lib\usblib\include\; ..\..\..\lib\cpu\include\armv7a\; ..\..\..\lib\utils\include\; ..\..\..\lib\font\; ..\..\..\lib\gui\; ..\..\..\src\include\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: project.srec
configuration Debug_yuanji (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: am335x; beaglebone; INNERBOOT; DEBUG_ERROR_NOTOUTPUT; YUANJI
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: boot_yj.mbt
configuration Release_yuanji (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone
  ICCARM.CCIncludePath2: ..\..\..\lib\peri_drivers\include\; ..\..\..\lib\peri_drivers\include\hw\; ..\..\..\lib\mmcsdlib\include\; ..\..\..\lib\platform\include\; ..\..\..\lib\cpu\include\; ..\..\..\lib\fatfs\src\; ..\..\..\lib\fatfs\port\; ..\..\..\lib\usblib\include\; ..\..\..\lib\cpu\include\armv7a\; ..\..\..\lib\utils\include\; ..\..\..\lib\font\; ..\..\..\lib\gui\; ..\..\..\src\include\; ..\..\..\src\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: project.srec
configuration Debug_YT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: am335x; beaglebone; INNERBOOT; DEBUG_ERROR_NOTOUTPUT; YITI
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: boot_yj.mbt
configuration Release_YT (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone; YITI
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: project.srec
  group lib/cpu
    ../../../lib/cpu/: clock.c interrupt.c startup.c
  group lib/cpu/armv7a
    ../../../lib/cpu/armv7a/: cache.c mmu.c
  group lib/cpu/armv7a/ewarm
    ../../../lib/cpu/armv7a/ewarm/: cp15.S cpu.S cpuinit.S
  group lib/cpu/ewarm
    ../../../lib/cpu/ewarm/: exceptionhandler.S
  group lib/fatfs/port
    ../../../lib/fatfs/port/: diskio.c diskio.h
  group lib/fatfs/scr
    ../../../lib/fatfs/src/: ff.c ff.h ff_ext.c ff_ext.h integer.h
  group lib/gui
    ../../../lib/gui/: ascii_16.c ascii_20.c ascii_24_fix.c font.c GUI_draw.c GUI_font.h GUI_SIF_Prop.c GUICharP.c GUIType.h lib_gui.h utf8.c utf8.h
  group lib/low_level_clib
    ../../../lib/low_level_clib/: time.c time64.c
  group lib/mmcsdlib
    ../../../lib/mmcsdlib/: hs_mmcsdlib.c mmcsd_proto.c mmcsd_proto_hooks.c mmcsdhost.c
  group lib/per_drivers
    ../../../lib/peri_drivers/: cppi41dma.c cpsw.c dcan.c dmtimer.c ecap.c edma.c ehrpwm.c elm.c gpio_v2.c gpmc.c hs_mmcsd.c hsi2c.c mailbox.c mcasp.c mcspi.c mdio.c phy.c raster.c rtc.c tsc_adc.c uart_irda_cir.c usb.c usbphyGS70.c watchdog.c
  group lib/platform
    ../../../lib/platform/: am335x_clock_data.c am335x_module_data.c pf_beep.c pf_bootloader.c pf_cpsw.c pf_dcan.c pf_dmtimer.c pf_dmtimerpwm.c pf_ecap.c pf_edma.c pf_eeprom.c pf_eventloop.c pf_gpio.c pf_hs_mmcsd.c pf_hsi2c.c pf_int.c pf_key_touchpad.c pf_lcd.c pf_misc.c pf_module.c pf_mux.h pf_norflash.c pf_pwmss.c pf_qep.c pf_rtc.c pf_rx8025.c pf_spi.c pf_sysdelay.c pf_sysperf.c pf_timertick.c pf_tsc.c pf_uart.c pf_usb.c pf_usbmsc.c pf_watchdog.c
  group lib/platform/include
    ../../../lib/platform/include/: pf_eeprom.h pf_platform_cfg.h
  group lib/usblib
    ../../../lib/usblib/: usbbuffer.c usbdata.c usbdesc.c usbkeyboardmap.c usbringbuf.c usbtick.c
  group lib/usblib/device
    ../../../lib/usblib/device/: usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbdenum.c usbdhandler.c usbdhid.c usbdhidmouse.c usbdmsc.c
  group lib/usblib/host
    ../../../lib/usblib/host/: usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhmsc.c usbhostenum.c usbhscsi.c
  group lib/utils
    ../../../lib/utils/: algorithm.c memery.c misc.c uartStdio.c
  group lib/utils/include
    ../../../lib/utils/include/: algorithm.h atomic.h debug.h mem.h misc.h mmath.h systick.h type.h uartstdio.h
  group linker
    ../../tool/ewarm/: boot.icf
  group src
    ../../../src/: bl_copy.c bl_main.c bl_platform.c burn.c emmc_header.c post.c test.c ui.c xo2_burn.c
  group src/board_siwaji_yt
    ../../../src/board_siwaji_yt/: board.c cfg.h
  group src/board_waji_m
    ../../../src/board_waji_m/: board.c cfg.h
  group src/board_yuanji
    ../../../src/board_yuanji/: board.c cfg.h
  group src/config
    ../../../src/config/: ffconf.h platform_cfg.h
  group src/xo2_burn/oc_i2c_port
    ../../../src/xo2_burn/oc_i2c_port/: oc_i2c_port.c oc_i2c_port.h
  group src/xo2_burn/XO2_ECA
    ../../../src/xo2_burn/XO2_ECA/: ECA_drvr.h XO2_api.c XO2_api.h XO2_cmds.c XO2_cmds.h XO2_dev.c XO2_dev.h
