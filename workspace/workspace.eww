<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\project\mmc_inand_fat\mmc_inand_fat.ewp</path>
  </project>
  <batchBuild/>
</workspace>


